# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\usr;..\..\..\..\mcu\stm32f103c8t6\STM32F1xx_HAL_Driver\Inc;..\..\..\..\mcu\stm32f103c8t6\CMSIS\Include;..\..\..\..\mcu\stm32f103c8t6\CMSIS\Device\ST\STM32F1xx\Include;..\..\usr\bsp;..\..\usr\core;..\..\..\..\elab;..\..\..\..\elab\common;..\..\..\..\elab\os;..\..\..\..\elab\os\mcu_noos;..\..\..\..\elab\3rd\list;..\..\..\..\elab\3rd\lwrb;..\..\..\..\elab\3rd\ringbuf;..\..\..\..\elab\3rd\state_machine;..\..\..\..\elab\3rd\Shell;..\..\..\..\elab\3rd\Unity;..\..\..\..\elab\elib;..\..\..\..\elab\3rd\xfusion;..\..\..\..\elab\3rd\xfusion\xf_utils_log;..\..\..\..\elab\3rd\RTT
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Template.sct
  link misc: --library_type=microlib
  group usr
    ../../usr/: main.c
  group core
    ../../usr/core/: stm32f1xx_hal_msp.c stm32f1xx_it.c
    ../../../../mcu/stm32f103c8t6/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../../../mcu/stm32f103c8t6/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group bsp
    ../../usr/bsp/: bsp.c led.c
  group stm32f103_hal
    ../../../../mcu/stm32f103c8t6/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_cortex.c
    ../../../../mcu/stm32f103c8t6/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_conf.h
  group cmsis_os
    ../../../../elab/os/mcu_noos/: cmsis_os2.c
  group Unity
    ../../../../elab/3rd/Unity/: unity.c unity_fixture.c unity_memory.c
  group unity_test
    ../../unity_test/: test_demo.c unity_export.c
