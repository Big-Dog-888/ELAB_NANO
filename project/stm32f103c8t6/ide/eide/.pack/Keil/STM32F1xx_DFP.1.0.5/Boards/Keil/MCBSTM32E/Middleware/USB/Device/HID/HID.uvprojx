# Keil uVision project HID.uvprojx, settings and files
target STM32F103 Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: HID
  c flags: Optim=4 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: HID.c USBD_User_HID_0.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.3/Boards/Keil/MCBSTM32E/Common/: GLCD_16bitIF_STM32F10x.c Joystick.c LED.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group ::Device
    RTE/Device/STM32F103ZE/: RTE_Device.h startup_stm32f10x_hd.s system_stm32f10x.c
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.3/RTE_Driver/: GPIO_STM32F10x.c
  group ::Drivers
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.3/RTE_Driver/: USBD_STM32F10x.c
  group ::USB
    RTE/USB/: USBD_Config_0.c USBD_Config_HID_0.h
    C:/Keil/ARM/PACK/Keil/MDK-Middleware/5.1.3/USB/Lib/ARM/: USB_CM3_L.lib
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.73.0, Board Support:MCBSTM32E:Graphic LCD 1.0.0, Board Support:MCBSTM32E:Joystick 1.0.0, Board Support:MCBSTM32E:LED 1.0.0, USB:CORE 5.0.4, USB:Device 5.0.4, USB:Device:HID 5.0.4, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:USB Device:Full-speed 1.0.0
