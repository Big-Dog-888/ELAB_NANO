# Keil uVision project GUIDemo.uvprojx, settings and files
target MCBSTM32E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c define: JOYSTICK_ROTATE
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group Device
    RTE/Device/STM32F103ZE/: startup_stm32f10x_hd.s system_stm32f10x.c RTE_Device.h
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: GPIO_STM32F10x.c
  group Board Support
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/Boards/Keil/MCBSTM32E/Common/: Joystick.c LCD_X_16bitIF_STM32F10x.c
  group CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil5/ARM/PACK/ARM/CMSIS/3.20.2/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group Graphics
    RTE/Graphics/: LCDConf_MCBQVGA_LD.c LCDConf_MCBQVGA_LG.c GUIConf.c
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/emWin/Lib/ARM/: GUI_CM3_L.lib
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/emWin/Sample/Application/GUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Graph.c GUIDEMO_Intro.c GUIDEMO_ListView.c GUIDEMO_Resource.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/emWin/Sample/GUI_X/: GUI_X_Joystick.c GUI_X_RTE.c
target MCBSTM32E LCD_LG (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: GUIDemo
  c flags: Optim=4
  c define: JOYSTICK_ROTATE
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.72.0, Board Support:MCBSTM32E:Joystick 1.0.0, Board Support:MCBSTM32E:emWin LCD 1.0.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Graphics:CORE 5.20.4, Graphics:Demo:Automotive 5.20.4, Graphics:Demo:Bitmap 5.20.4, Graphics:Demo:ColorBar 5.20.4, Graphics:Demo:Cursor 5.20.4, Graphics:Demo:Framework 5.20.4, Graphics:Demo:Graph 5.20.4, Graphics:Demo:ListView 5.20.4, Graphics:Demo:Speed 5.20.4, Graphics:Demo:TransparentDialog 5.20.4, Graphics:Demo:Treeview 5.20.4, Graphics:Display:MCBQVGA_LD 5.20.4, Graphics:Display:MCBQVGA_LG 5.20.4, Graphics:Input Device:Joystick 5.20.4
