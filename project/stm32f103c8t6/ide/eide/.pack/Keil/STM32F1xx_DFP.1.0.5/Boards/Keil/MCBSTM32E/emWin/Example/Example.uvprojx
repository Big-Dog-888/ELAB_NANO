# Keil uVision project Example.uvprojx, settings and files
target MCBSTM32E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Example
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group Device
    RTE/Device/STM32F103ZE/: startup_stm32f10x_hd.s system_stm32f10x.c RTE_Device.h
  group Board Support
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/Boards/Keil/MCBSTM32E/Common/: LCD_X_16bitIF_STM32F10x.c
  group CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil5/ARM/PACK/ARM/CMSIS/3.20.2/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group Graphics
    RTE/Graphics/: LCDConf_MCBQVGA_LD.c LCDConf_MCBQVGA_LG.c GUIConf.c
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/emWin/Lib/ARM/: GUI_CM3_L.lib
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/emWin/Sample/GUI_X/: GUI_X_RTE.c
target MCBSTM32E LCD_LG (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Example
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.72.0, Board Support:MCBSTM32E:emWin LCD 1.0.0, Device:Startup 1.0.0, Graphics:CORE 5.20.4, Graphics:Display:MCBQVGA_LD 5.20.4, Graphics:Display:MCBQVGA_LG 5.20.4
