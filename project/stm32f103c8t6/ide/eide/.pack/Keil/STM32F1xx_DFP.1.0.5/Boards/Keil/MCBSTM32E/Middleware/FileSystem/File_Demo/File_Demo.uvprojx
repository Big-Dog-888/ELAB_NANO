# Keil uVision project File_Demo.uvprojx, settings and files
target STM32F103 Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: File_Demo
  c flags: Optim=4
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: File_Demo.c Getline.c
  group Documentation
    ./: Abstract.txt
  group Device
    RTE/Device/STM32F103ZE/: RTE_Device.h startup_stm32f10x_hd.s system_stm32f10x.c
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
  group Drivers
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: MCI_STM32F10x.c
  group CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil5/ARM/PACK/ARM/CMSIS/3.20.2/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group File System
    RTE/File_System/: FS_Config.c FS_Config_MC_0.h
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/FileSystem/Lib/ARM/: FS_LFN_CM3_L.lib
  group Board Support
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/Boards/Keil/MCBSTM32E/Common/: GLCD_16bitIF_STM32F10x.c
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.72.0, Board Support:MCBSTM32E:Graphic LCD 1.0.0, File System:CORE 5.0.4, File System:Drive:Memory Card 5.0.4, Device:DMA 1.0.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:MCI 1.01.0
